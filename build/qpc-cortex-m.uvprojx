# Keil uVision project qpc-cortex-m.uvprojx, settings and files
target qpc-cortex-m (6220000::V6.22::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qpc_cortex_m +hex
  AfterMake: fromelf.exe --bin --output .\bin\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,USE_FULL_LL_DRIVER,HSE_VALUE=12000000,
  c include: ..;../include;../include/port;../third_party/qpc/include;../third_party/qpc/ports/freertos;../third_party/SEGGER_RTT/RTT;../third_party/SEGGER_RTT/Config;..\third_party\STM32Cube_Driver\Drivers\STM32G4xx_HAL_Driver\Inc;..\third_party\STM32Cube_Driver\Drivers\CMSIS\Device\ST\STM32G4xx\Include;../third_party/STM32Cube_MX/Core/Inc;../third_party/FreeRTOS/FreeRTOS-Kernel/include;../third_party/FreeRTOS/FreeRTOS-Kernel/portable/GCC/ARM_CM4F;../third_party/FreeRTOS/FreeRTOS-Kernel/portable/MemMang;../third_party/FreeRTOS/port
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bl
    ../src/bl/: bzero.c delay.c log.c memmem.c retarget.c rtt.cpp
  group dl
    ../src/dl/: system.c bsp.c boot.c main.c
  group sl
    ../src/sl/: gpio.cpp led.cpp kb.cpp
  group al
    ../src/al/: app.cpp
  group qm
    ../src/qm/: qm_boot.cpp qm_main.cpp qm_app.cpp qm_kb.cpp qm_led.cpp qm_rtt.cpp
  group qpc
    ../third_party/qpc/src/qf/: qf_time.c qf_qmact.c qf_qeq.c qf_ps.c qf_mem.c qf_dyn.c qf_defer.c qf_act.c qep_msm.c qep_hsm.c qf_qact.c
  group qpc-port
    ../third_party/qpc/ports/freertos/: qf_port.c
  group SEGGER_RTT
    ../third_party/SEGGER_RTT/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group STM32Cube_Driver
    ../third_party/STM32Cube_Driver/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_utils.c stm32g4xx_ll_rcc.c stm32g4xx_ll_gpio.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c
  group STM32Cube_MX
    ../third_party/STM32Cube_MX/Core/Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c system_stm32g4xx.c gpio.c
    ../third_party/STM32Cube_MX/MDK-ARM/: startup_stm32g431xx.s
  group FreeRTOS_Kernel
    ../third_party/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_port
    ../third_party/FreeRTOS/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ../third_party/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 6.1.0
